# Keil uVision project A4988.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\user;.\driver\inc;.\SYSTEM\delay;.\SYSTEM\usart;.\SYSTEM\sys;.\HARDWARE\SPI;.\HARDWARE\TLC2543;.\SYSTEM\timer;.\HARDWARE\A4988;.\HARDWARE\TIMER;.\HARDWARE\42Stepper
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: stm32f10x_it.c
    ./: main.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_cl.s
  group driver
    ./driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
  group HARDWARE
    ./HARDWARE/A4988/: A4988.c A4988.h
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/42Stepper/: 42Stepper.c 42Stepper.h
